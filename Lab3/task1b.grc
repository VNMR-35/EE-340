options:
  parameters:
    author: Vinamra
    generate_options: qt_gui
    id: lab3_task1b
    output_language: python
    title: Lab 3 Task 1B
  states: {}

blocks:
- name: samp_msg
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '3528000'
  states: {}
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_abs_xx_0_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\vinam\Documents\Semester_5\EE 340\Lab3\task1br.dat
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\vinam\Documents\Semester_5\EE 340\Lab3\music.wav
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '100'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/6.28
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '10'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '10'
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_1_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_msg
    type: float
  states: {}
- name: blocks_throttle_1_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_msg
    type: float
  states: {}
- name: blocks_throttle_1_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_msg
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '8'
    file: /home/ipsit/Documents/EE 340/Lab 3/task1b.wav
    samp_rate: samp_msg
  states: {state: disabled}
- name: blocks_wavfile_sink_0_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '8'
    file: /home/ipsit/Documents/EE 340/Lab 3/task1br.wav
    samp_rate: samp_msg
  states: {state: disabled}
- name: blocks_wavfile_sink_0_0_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '8'
    file: /home/ipsit/Documents/EE 340/Lab 3/task1bi.wav
    samp_rate: samp_msg
  states: {state: disabled}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '10000'
    long_form: 'True'
    type: ff
  states: {}
- name: dc_blocker_xx_0_0
  id: dc_blocker_xx
  parameters:
    length: '32000'
    long_form: 'True'
    type: ff
  states: {}
- name: dc_blocker_xx_0_0_0
  id: dc_blocker_xx
  parameters:
    length: '10000'
    long_form: 'True'
    type: ff
  states: {}
- name: iir_filter_xxx_0
  id: iir_filter_xxx
  parameters:
    fbtaps: '1'
    fftaps: '[1,-1]'
    type: ffd
  states: {}
- name: iir_filter_xxx_0_0
  id: iir_filter_xxx
  parameters:
    fbtaps: '1'
    fftaps: '[1,-1]'
    oldstyle: 'False'
    type: ffd
  states: {}
- name: iir_filter_xxx_2
  id: iir_filter_xxx
  parameters:
    fbtaps: '[1,-0.95]'
    fftaps: '1'
    oldstyle: 'False'
    type: ffd
  states: {}
- name: iir_filter_xxx_2_0
  id: iir_filter_xxx
  parameters:
    fbtaps: '[1,-0.95]'
    fftaps: '1'
    oldstyle: 'False'
    type: ffd
  states: {}
- name: iir_filter_xxx_2_0_0
  id: iir_filter_xxx
  parameters:
    fbtaps: '[1,-0.95]'
    fftaps: '1'
    oldstyle: 'False'
    type: ffd
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: '15000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: firdes.WIN_KAISER
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '15000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '15000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_msg
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@1
    name: Demodulated
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_msg
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@2
    name: Demodulated (only Real)
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_msg
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@3
    name: Demodulated (only Imag)
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@0
    name: Modulated
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: samp_msg
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: samp_msg
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: samp_msg
    taps: ''
    type: fff
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: Modulated
    label1: Demodulated
    label2: Demodulated (only Real)
    label3: Demodulated (only Imag)
    num_tabs: '4'
  states: {}

connections:
- [blocks_abs_xx_0, '0', low_pass_filter_1, '0']
- [blocks_abs_xx_0_0, '0', low_pass_filter_1_0, '0']
- [blocks_complex_to_arg_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_complex_to_imag_0, '0', iir_filter_xxx_0_0, '0']
- [blocks_complex_to_real_0, '0', iir_filter_xxx_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_1, '0']
- [blocks_delay_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_file_source_0, '0', blocks_complex_to_imag_0, '0']
- [blocks_file_source_0, '0', blocks_complex_to_real_0, '0']
- [blocks_file_source_0, '0', blocks_delay_0, '0']
- [blocks_file_source_0, '0', blocks_multiply_xx_1, '1']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_throttle_1_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', blocks_throttle_1_0_0, '0']
- [blocks_multiply_const_vxx_0_1_0, '0', blocks_throttle_1_0_0_0, '0']
- [blocks_multiply_xx_1, '0', blocks_complex_to_arg_0, '0']
- [blocks_throttle_0, '0', qtgui_sink_x_1, '0']
- [blocks_throttle_1_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_throttle_1_0, '0', qtgui_sink_x_0, '0']
- [blocks_throttle_1_0_0, '0', blocks_file_sink_0, '0']
- [blocks_throttle_1_0_0, '0', blocks_wavfile_sink_0_0, '0']
- [blocks_throttle_1_0_0, '0', qtgui_sink_x_0_0, '0']
- [blocks_throttle_1_0_0_0, '0', blocks_wavfile_sink_0_0_0, '0']
- [blocks_throttle_1_0_0_0, '0', qtgui_sink_x_0_0_0, '0']
- [dc_blocker_xx_0, '0', rational_resampler_xxx_0_0, '0']
- [dc_blocker_xx_0_0, '0', rational_resampler_xxx_0_0_0, '0']
- [dc_blocker_xx_0_0_0, '0', rational_resampler_xxx_0_0_0_0, '0']
- [iir_filter_xxx_0, '0', blocks_abs_xx_0, '0']
- [iir_filter_xxx_0_0, '0', blocks_abs_xx_0_0, '0']
- [iir_filter_xxx_2, '0', blocks_multiply_const_vxx_0, '0']
- [iir_filter_xxx_2_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [iir_filter_xxx_2_0_0, '0', blocks_multiply_const_vxx_0_1_0, '0']
- [low_pass_filter_0, '0', dc_blocker_xx_0, '0']
- [low_pass_filter_1, '0', dc_blocker_xx_0_0, '0']
- [low_pass_filter_1_0, '0', dc_blocker_xx_0_0_0, '0']
- [rational_resampler_xxx_0_0, '0', iir_filter_xxx_2, '0']
- [rational_resampler_xxx_0_0_0, '0', iir_filter_xxx_2_0, '0']
- [rational_resampler_xxx_0_0_0_0, '0', iir_filter_xxx_2_0_0, '0']

metadata:
  file_format: 1
