options:
  parameters:
    author: Vinamra
    generate_options: qt_gui
    id: lab3_task2
    output_language: python
    title: Lab 3 Task 2
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\vinam\Documents\Semester_5\EE 340\Lab3\task1.dat
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_transcendental_0
  id: blocks_transcendental
  parameters:
    name: sqrt
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '8'
    file: C:\Users\vinam\Documents\Semester_5\EE 340\Lab3\task2.wav
    samp_rate: samp_rate
  states: {}
- name: iir_filter_xxx_0
  id: iir_filter_xxx
  parameters:
    fbtaps: '1'
    fftaps: '[1,-1]'
    type: ffd
  states: {}
- name: iir_filter_xxx_0_0
  id: iir_filter_xxx
  parameters:
    fbtaps: '1'
    fftaps: '[1,-1]'
    type: ffd
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '30000'
    decim: '1'
    gain: '10'
    samp_rate: '5000000'
    type: fir_filter_fff
    width: '20000'
    win: firdes.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5000000'
    interp: '44100'
    taps: ''
    type: fff
  states: {}

connections:
- [blocks_abs_xx_0, '0', blocks_transcendental_0, '0']
- [blocks_complex_to_real_0, '0', blocks_multiply_xx_1_0, '1']
- [blocks_complex_to_real_0, '0', iir_filter_xxx_0, '0']
- [blocks_file_source_0, '0', blocks_complex_to_real_0, '0']
- [blocks_multiply_xx_1, '0', blocks_sub_xx_0, '0']
- [blocks_multiply_xx_1_0, '0', blocks_sub_xx_0, '1']
- [blocks_sub_xx_0, '0', blocks_abs_xx_0, '0']
- [blocks_throttle_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_transcendental_0, '0', low_pass_filter_0, '0']
- [iir_filter_xxx_0, '0', blocks_multiply_xx_1, '0']
- [iir_filter_xxx_0, '0', blocks_multiply_xx_1, '1']
- [iir_filter_xxx_0, '0', iir_filter_xxx_0_0, '0']
- [iir_filter_xxx_0_0, '0', blocks_multiply_xx_1_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
