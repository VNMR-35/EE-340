options:
  parameters:
    author: vinam
    generate_options: qt_gui
    id: lab4_task1b
    output_language: python
    title: Lab 4 Task 1B
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '320000'
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_1_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '32000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\vinam\Documents\Semester_5\EE 340\Lab4\data1.dat
    repeat: 'True'
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '32000'
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '25000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '2000'
    win: firdes.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: samp_rate_0
    taps: ''
    type: fff
  states: {}

connections:
- [analog_sig_source_x_1_0, '0', blocks_multiply_xx_1, '0']
- [blocks_file_source_0, '0', blocks_multiply_xx_1, '1']
- [blocks_multiply_xx_1, '0', low_pass_filter_0, '0']
- [blocks_throttle_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
